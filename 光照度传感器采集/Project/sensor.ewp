# IAR project sensor.ewp, settings and files
configuration gm_sensor (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: GM_SENDOR
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\mylib; ..\CC2530_lib\moudle; ..\sensor_drv
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration qt_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: QT_SENDOR
configuration collect (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\moudle
  group app
    ./: collect.c sensor.c
  group basicrf
    ../CC2530_lib/basicrf/: basic_rf.r51
  group board
    ../CC2530_lib/board/: hal_board.c hal_led.c
  group common
    ../CC2530_lib/common/: hal_adc.c hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c hal_uart.c
  group mylib
    ../CC2530_lib/mylib/: TIMER.c UART_PRINT.c
  group sensor_drv
    ../sensor_drv/: get_adc.c get_swsensor.c sh10.c
  group utils
    ../CC2530_lib/utils/: util.c
